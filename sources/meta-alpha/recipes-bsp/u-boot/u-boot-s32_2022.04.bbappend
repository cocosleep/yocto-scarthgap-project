URL = "git://github.com/cocosleep/u-boot-s32.git;protocol=https"
BRANCH = "master"

SRCREV = "${AUTOREV}"

COMPATIBLE_MACHINE = "s32g399aalpha"