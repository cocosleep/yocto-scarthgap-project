URL = "git://github.com/cocosleep/linux-s32.git;protocol=https"
BRANCH = "master"

SRCREV = "${AUTOREV}"

COMPATIBLE_MACHINE = "s32g399aalpha"